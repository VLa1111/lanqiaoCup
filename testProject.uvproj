# Keil uVision project testProject.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: testProject +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\3-底层驱动代码参考
  group Source Group 1
    ./: main.c
